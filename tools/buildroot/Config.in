## tools/buildroot/Config.in
```kconfig
config BR2_PACKAGE_XWIIMOTE
	bool "xwiimote"
	help
		Open Source Nintendo Wii Remote Linux Device Driver
```
